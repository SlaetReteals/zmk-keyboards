## boards/shields/slaetjoystick/Kconfig.defconfig
```kconfig
if SHIELD_SLAETJOYSTICK

config ZMK_KEYBOARD_NAME
    default "Slaet Joystick"

endif
```
